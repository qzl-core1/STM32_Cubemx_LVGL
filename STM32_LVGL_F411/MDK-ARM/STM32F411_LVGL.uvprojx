# Keil uVision project STM32F411_LVGL.uvprojx, settings and files
target STM32F411_LVGL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F411_LVGL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;         C:/Users/qzl/STM32Cube/Repository/STM32Cube_FW_F4_V1.26.2/Drivers/STM32F4xx_HAL_Driver/Inc;         C:/Users/qzl/STM32Cube/Repository/STM32Cube_FW_F4_V1.26.2/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;         C:/Users/qzl/STM32Cube/Repository/STM32Cube_FW_F4_V1.26.2/Drivers/CMSIS/Device/ST/STM32F4xx/Include;         C:/Users/qzl/STM32Cube/Repository/STM32Cube_FW_F4_V1.26.2/Drivers/CMSIS/Include;         .\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    C:/Users/qzl/STM32Cube/Repository/STM32Cube_FW_F4_V1.26.2/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drive
    ./Lib/: ST7789.c
  group LVGL
    ./Lib/lvgl/porting/: lv_port_disp_template.c
    ./Lib/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ./Lib/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./Lib/lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c
    ./Lib/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./Lib/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./Lib/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ./Lib/lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group Picture
    ./Lib/: baijia.c
software components: CMSIS:CORE 4.3.0
